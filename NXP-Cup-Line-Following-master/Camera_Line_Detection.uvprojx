# Keil uVision project Camera_Line_Detection.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.13.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Camera_Line_Detection
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./: main.c UARTHandler.c TFCHandler.c CameraHandler.c CameraDriver.c TimerDriver.c PITDriver.c ServoDriver.c MotorDriver.c
software components: CMSIS:CORE 4.3.0, Board Support:LED 1.0.0, Device:Startup 2.5.0
